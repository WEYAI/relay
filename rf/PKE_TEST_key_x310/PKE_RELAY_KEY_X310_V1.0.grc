options:
  parameters:
    generate_options: qt_gui
    id: RKE_RELAY
    output_language: python
    title: RKE_RELAY
  states: {}

blocks:
- name: lf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '30'
    value: '5'
  states: {}
- name: lfrx_freq
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: lftx_freq
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: offset
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: ubx_rx_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: ubx_rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '31'
    value: '30'
  states: {}
- name: ubx_tx_freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: ubx_tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '31'
    value: '30'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: lf_gain
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: lfrx_freq  + offset
    fftsize: '1024'
    gui_hint: 2,0,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: ubx_rx_freq  + offset
    fftsize: '1024'
    gui_hint: 2,1,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    ant1: TX/RX
    center_freq0: lftx_freq + offset
    center_freq1: ubx_tx_freq  + offset
    dev_args: '""'
    gain0: '100'
    gain1: ubx_tx_gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: RX2
    center_freq0: lfrx_freq + offset
    center_freq1: ubx_rx_freq  + offset
    comment: |-
      LF 接收 25MHz 信号，再变频到 125e3 LF 发射。
      UBX 接收 433.92MHZ， 再变频到900MHz
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_args: '""'
    gain0: '10'
    gain1: ubx_rx_gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1

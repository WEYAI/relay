options:
  parameters:
    generate_options: qt_gui
    id: RKE_RELAY
    output_language: python
    title: RKE_RELAY
  states: {}

blocks:
- name: lf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '30'
    value: '5'
  states: {}
- name: lfrx_freq
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: lftx_freq
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: offset
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ubx_rx_freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: ubx_rx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain_range
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '31'
    value: '30'
  states: {}
- name: ubx_tx_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: ubx_tx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain_range
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '31'
    value: '30'
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: lf_gain
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: ubx_rx_freq + offset
    fftsize: '1024'
    gui_hint: 2,1,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '5'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: lfrx_freq + offset
    fftsize: '1024'
    gui_hint: 2,0,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    center_freq0: lftx_freq + offset
    dev_args: '""'
    gain0: '10'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: ubx_tx_freq + offset
    dev_args: '""'
    gain0: ubx_tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    center_freq0: lfrx_freq + offset
    comment: |-
      LF 接收 125e3 信号，再变频到 25MHz LF 发射。
      UBX 接收 900MHZ， 再变频到 433.92MHz
    dc_offs_enb0: '""'
    dev_args: '"type=usrp2"'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: ubx_rx_freq + offset
    comment: |-
      LF 接收 125e3 信号，再变频到 25MHz LF 发射。
      UBX 接收 900MHZ， 再变频到 433.92MHz
    dc_offs_enb0: '""'
    dev_args: '"type=b200"'
    gain0: ubx_rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_1_0, '0', uhd_usrp_sink_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [uhd_usrp_source_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', uhd_usrp_sink_0_0_0, '0']

metadata:
  file_format: 1
